# Keil uVision project OLED_CLOCK_TH.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: OLED_CLOCK_TH +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: startup.a51 main.c
