# Keil uVision project OLED_CLOCK_TH.uvproj, settings and files
target code (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: OLED_CLOCK_TH +hex
  c flags: Optimize=8 SizeSpeed=1
  group usr
    ./code/: display.c gp_sub.c key_func.c main.c oled_12832.c rtc.c si7021.c main_sub.c common.c
