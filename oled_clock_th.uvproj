# Keil uVision project oled_clock_th.uvproj, settings and files
target code (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: oled_clock_th +hex
  c flags: Optimize=8 SizeSpeed=1
  group usr
    ./code/: common.c display.c gp_sub.c key_func.c main.c main_sub.c oled_12832.c rtc.c si7021.c
